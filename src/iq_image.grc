options:
  parameters:
    generate_options: qt_gui
    id: iq_image
    output_language: python
    title: iq_image
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom PIL import Image\nimport numpy as np\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def _get_iq_image(self, input_file):\n        # 读取图片\n        image = Image.open(input_file)\n\n        # 将图片转换为灰度图\n        gray_image = image.convert('L')\n\n        # 将灰度图转换为mxn的数组\n        image_array = np.array(gray_image)\n\n        # 设定阈值，这里取128\n        threshold = 128\n        # 进行二值化处理\n        binary_image_array = np.where(image_array > threshold, 255, 0).astype(np.uint8)\n\n        # 将二值化后的数组转换回图片\n        binary_image = Image.fromarray(binary_image_array)\n\n        # 保存二值化后的图片\n        binary_image.save('binary_example.jpg')\n\n        # 创建一个空列表用于存储坐标复数\n        output = []\n\n        # 遍历二值化图像数组\n        rows, columns = binary_image_array.shape\n        normalization = max(rows, columns) \n        for i in range(rows):\n            gnuradio_signal = 0\n            for j in range(columns):\n                if binary_image_array[i][j] == 0:\n                    # 创建一个复数表示坐标\n                    gnuradio_iq = complex((j-columns/2)/normalization*2, -(i-rows/2)/normalization*2)\n                    output.append(gnuradio_iq)\n            \n        print(f\"image:{rows}x{columns}\")\n        # print(output)\n\n        # 将输出列表转换为NumPy数组\n        output_np = np.array(output, dtype=np.complex64)\n        return output_np\n\n    def __init__(self, input_file=\"/home/robot/buaa2spec/src/buaa.jpg\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.iq_image = self._get_iq_image(input_file)\n        \n        self.iq_image_read_index = 0\n        self.iq_image_len = len(self.iq_image)\n       \n\n    def work(self, input_items, output_items):\n        o_len = len(output_items[0])\n        for i in range(o_len):\n            self.iq_image_read_index += 1\n            if self.iq_image_read_index >=  self.iq_image_len:\n                self.iq_image_read_index = 0\n                print(\"one loop\")\n                \n            output_items[0][i] = self.iq_image[self.iq_image_read_index]\n        return len(output_items[0])\n        \n        \n"
    input_file: '"/home/robot/buaa2spec/src/buaa.jpg"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
