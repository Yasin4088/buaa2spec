options:
  parameters:
    generate_options: qt_gui
    id: waterfall_image
    output_language: python
    title: waterfall_image
  states: {}

blocks:
- name: img_width
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12800'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: img_width
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom PIL import Image\n\n\nclass blk(gr.sync_block):\n    \"\"\"Embedded Python Block example - convert image to frequency-domain data for waterfall plot\"\"\"\n\n    def _get_iq_image(self, input_file):\n        # 读取图片\n        image = Image.open(input_file)\n        # 将图片转换为灰度图\n        gray_image = image.convert('L')\n        gray_image = gray_image.resize((512, 512))\n        # 将灰度图转换为mxn的数组\n        image_array = np.array(gray_image)\n        # 设定阈值，这里取128\n        threshold = 128\n        # 进行二值化处理\n        binary_image_array = np.where(image_array > threshold, 255, 0).astype(np.uint8)\n        # 将二值化后的数组转换回图片\n        binary_image = Image.fromarray(binary_image_array)\n        # 保存二值化后的图片\n        binary_image.save('binary_example.jpg')\n\n        rows, columns = binary_image_array.shape\n        frequency_step = 10e3  # 10 kHz 频率步长\n        iq_image = []\n        for i in range(rows):\n            # 初始化当前行的频谱数据\n            spectrum = np.zeros(columns, dtype=np.complex64)\n            for j in range(columns):\n                if binary_image_array[i][j] == 0:\n                    # 当第 j 个位置为 0 时，让 j * 10 kHz 的频率有效\n                    spectrum[j] = 1.0 + 0j\n            iq_image.append(spectrum)\n        return np.array(iq_image, dtype=np.complex64)\n\n    def __init__(self, input_file=\"/home/robot/buaa2spec/src/buaa.jpg\", venctor_len=512):\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block2',  # will show up in GRC\n            in_sig=[],\n            # 修改输出信号为向量类型，每个向量长度为列数\n            out_sig=[(np.complex64, venctor_len)]\n        )\n        self.iq_image = self._get_iq_image(input_file)\n        self.current_row = 0\n        self.rows, self.columns = self.iq_image.shape\n        self.set_output_multiple(self.columns)\n\n    def work(self, input_items, output_items):\n        o_len = len(output_items[0])\n        for i in range(o_len):\n            if self.current_row >= self.rows:\n                self.current_row = 0\n            output_items[0][i] = self.iq_image[self.current_row]\n            self.current_row += 1\n        return o_len\n\n"
    input_file: '"/home/robot/buaa2spec/src/buaa.jpg"'
    venctor_len: img_width
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: img_width
    forward: 'False'
    nthreads: '10'
    shift: 'True'
    type: complex
    window: window.rectangular(img_width)
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: img_width
    type: complex
    wintype: window.WIN_NONE
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [epy_block_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
